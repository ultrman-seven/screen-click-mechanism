# Keil uVision project fw.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fw
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\UserCode;..\lib;..\lib\CMSIS;..\lib\Include;..\lib\mm32CppWyHAL
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Hal
    ../lib/: cppHalReg.cpp
    ../lib/mm32CppWyHAL/: wyAdc.cpp wyDma.cpp wyFlash.cpp wyGpio.cpp wyI2c.cpp wyIstream.cpp wyOstream.cpp wySpi.cpp wySys.cpp wyTimer.cpp wyUart.cpp
  group StartUp
    ../lib/: system_mm32f0010.c startup_mm32f0010_keil.s
  group User
    ../UserCode/: board.cpp communication.cpp main.cpp
